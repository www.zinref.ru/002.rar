# KOMPAS-3D drawing (Чертеж.cdw)

Views: Вид 1
Texts:
  илья
  конвейер л1000ку
Dimensions and other numbers on the sheet: 1; 7; 8; 9